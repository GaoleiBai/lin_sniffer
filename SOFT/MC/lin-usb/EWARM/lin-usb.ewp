# IAR project lin-usb.ewp, settings and files
configuration lin-usb Configuration (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F103xB
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc; ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy; ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc; ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: lin-usb Configuration.out
  ILINK.IlinkIcfFile: stm32f103xb_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/iar/: startup_stm32f103xb.s startup_stm32f103xb.s
  group Application/User
    ../Src/: gpio.c lin.c main.c stm32f1xx_hal_msp.c stm32f1xx_it.c usart.c usb_device.c usbd_cdc_if.c usbd_conf.c usbd_desc.c usart.c stm32f1xx_hal_msp.c main.c usb_device.c stm32f1xx_it.c usbd_cdc_if.c gpio.c usbd_desc.c usbd_conf.c
  group Application/
    ./: 
  group Application/
    ./: 
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_ll_usb.c stm32f1xx_hal_gpio_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal.c stm32f1xx_hal_pwr.c
  group Drivers/
    ./: 
  group Drivers/
    ./: 
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c usbd_ioreq.c usbd_core.c usbd_ctlreq.c
  group Middlewares/
    ./: 
